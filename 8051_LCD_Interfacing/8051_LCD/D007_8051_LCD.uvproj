# Keil uVision project D007_8051_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LV51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: D007_8051_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 8051_LCD.A51
