# Keil uVision project 8051_KEYBOARD_SSD.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LV51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: 8051_KEYBOARD_SSD
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 8051_KEYBOARD_SSD_ASMHeader.a51
